DESCRIPTION = "Linux kernel for ABCom IPBOX 91HD, Sezam 900HD, VIZYON-800HD"

require linux-cuberevo-${STM_RELEASE}.inc
