DESCRIPTION = "Linux kernel for (CubeRevo 7000HD)"

require linux-cuberevo-${STM_RELEASE}.inc
