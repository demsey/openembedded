
require stmfb.inc

SRC_URI[stmfb.md5sum] = "eaaa37034a0811cc8b138a48459dcf30"
SRC_URI[stmfb.sha256sum] = "ffdb30dc74a0c9fea9177eae2245a6b391a74d7cee3938d09180152e909014ce"

